/*****************************************************************************
* Copyright (c) [2019] - [2026], Argenox Technologies LLC
* All rights reserved.
* SPDX-License-Identifier: GPL-2.0-or-later OR NoxTLS-Commercial
*
*
* This file is part of the NoxTLS Library.
*
* Licensed under the GNU General Public License v2.0 or later,
* or alternatively under a commercial license from
* Argenox Technologies LLC.
*
* See the LICENSE file in the project root for full details.
* CONTACT: info@argenox.com
*
*
* File:    noxtls_speed_pk.c
* Summary: P-256 cases of the EFR32xG26 NoxTLS speed benchmark
*
*****************************************************************************/

/**
 * @file noxtls_speed_pk.c
 * @brief Software versus Secure Engine timing of P-256 key generation, ECDH and ECDSA.
 * @ingroup noxtls_speed
 *
 * Key generation and ECDSA signing draw random numbers (the Secure Engine nonce
 * differs from the software nonce), so they cannot be compared byte for byte.
 * They are cross-checked instead: a key made by one backend must have
 * Q = d * G when recomputed by the other, and a signature made by one backend
 * must verify under both. ECDH and ECDSA verification are deterministic and
 * are compared directly.
 */

#include <stddef.h>
#include <string.h>

#include "pkc/ecdh/noxtls_ecdh.h"
#include "pkc/ecdsa/noxtls_ecdsa.h"
#include "pkc/ecc/noxtls_ecc.h"
#include "noxtls_efr32_accel.h"

#include "noxtls_speed_bench.h"
#include "noxtls_speed_config.h"
#include "noxtls_speed_timer.h"

/** @brief Multiplier of the digest pattern. */
#define SPEED_DIGEST_MUL        11U
/** @brief Offset of the digest pattern. */
#define SPEED_DIGEST_ADD        5U

/** @brief Key generated by the software backend. */
static ecc_key_t s_key_sw;
/** @brief Key generated by the hardware backend. */
static ecc_key_t s_key_hw;
/** @brief Scratch key of the timed loops. */
static ecc_key_t s_key_tmp;
/** @brief Whether s_key_sw holds a key. */
static uint8_t s_have_sw;
/** @brief Whether s_key_hw holds a key. */
static uint8_t s_have_hw;
/** @brief Whether s_key_tmp holds a key. */
static uint8_t s_have_tmp;
/** @brief Message digest that is signed. */
static uint8_t s_digest[NOXTLS_SPEED_P256_BYTES];
/** @brief Signature made by the software backend. */
static ecdsa_signature_t s_sig_sw;
/** @brief Signature made by the hardware backend. */
static ecdsa_signature_t s_sig_hw;
/** @brief Scratch signature of the timed loops. */
static ecdsa_signature_t s_sig_tmp;

/**
 * @brief Release a key if it holds one.
 * @internal
 *
 * @param[in,out] key  Key.
 * @param[in,out] have Allocation flag, cleared.
 */
static void speed_key_release(ecc_key_t *key, uint8_t *have)
{
    if (*have != 0U) {
        (void)noxtls_ecc_key_free(key);
        *have = 0U;
    }
}

/**
 * @brief Generate a P-256 key into the scratch key (releasing the previous one).
 * @internal
 *
 * @return Library result.
 */
static noxtls_return_t speed_keygen_tmp(void)
{
    noxtls_return_t rc;

    speed_key_release(&s_key_tmp, &s_have_tmp);
    rc = noxtls_ecc_key_generate(&s_key_tmp, NOXTLS_ECC_SECP256R1);
    if (rc == NOXTLS_RETURN_SUCCESS) {
        s_have_tmp = 1U;
    }
    return rc;
}

/**
 * @brief Whether Q = d * G holds, recomputed on the backend currently selected.
 * @internal
 *
 * @param[in] key Key.
 *
 * @return 1 when it holds, 0 otherwise.
 */
static uint8_t speed_pub_matches(const ecc_key_t *key)
{
    const ecc_curve_params_t *curve = noxtls_ecc_curve_get(NOXTLS_ECC_SECP256R1);
    ecc_point_t result;
    uint8_t good = 0U;

    if ((curve != NULL) && (key->d != NULL)) {
        (void)memset(&result, 0, sizeof(result));
        if (noxtls_ecc_point_multiply(&result, key->d, &curve->G, curve) == NOXTLS_RETURN_SUCCESS) {
            good = ((memcmp(result.x, key->Q.x, NOXTLS_SPEED_P256_BYTES) == 0) &&
                    (memcmp(result.y, key->Q.y, NOXTLS_SPEED_P256_BYTES) == 0)) ? 1U : 0U;
        }
    }
    return good;
}

/**
 * @brief Time P-256 key generation on both backends and cross-check the keys.
 * @internal
 */
static void speed_case_keygen(void)
{
    noxtls_speed_row_t *row = noxtls_speed_row_begin("p256_keygen", 0U, 1U);
    uint8_t ok = 1U;
    uint8_t match = 1U;
    uint32_t start;
    uint32_t activity;
    uint32_t i;

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    ok &= (speed_keygen_tmp() == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_keygen_tmp() == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->sw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);
    speed_key_release(&s_key_sw, &s_have_sw);
    s_key_sw = s_key_tmp;
    s_have_sw = s_have_tmp;
    s_have_tmp = 0U;

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_HW);
    ok &= (speed_keygen_tmp() == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    activity = noxtls_speed_hw_activity();
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_keygen_tmp() == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->hw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);
    row->hw_used = (noxtls_speed_hw_activity() != activity) ? 1U : 0U;
    speed_key_release(&s_key_hw, &s_have_hw);
    s_key_hw = s_key_tmp;
    s_have_hw = s_have_tmp;
    s_have_tmp = 0U;

    /* Each key must be consistent when recomputed by the other backend. */
    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_HW);
    match &= speed_pub_matches(&s_key_sw);
    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    match &= speed_pub_matches(&s_key_hw);

    row->run_ok = ok;
    row->match = match;
    noxtls_speed_row_end(row);
}

/**
 * @brief ECDH shared secret of two keys.
 * @internal
 *
 * @param[in,out] priv   Our key.
 * @param[in]     peer   Peer key (its public point is used).
 * @param[out]    secret Shared secret.
 *
 * @return Library result.
 */
static noxtls_return_t speed_ecdh(ecc_key_t *priv, const ecc_key_t *peer, uint8_t *secret)
{
    uint32_t len = NOXTLS_SPEED_P256_BYTES;
    noxtls_return_t rc = noxtls_ecdh_compute_shared_secret(priv, &peer->Q, secret, &len);

    if ((rc == NOXTLS_RETURN_SUCCESS) && (len != NOXTLS_SPEED_P256_BYTES)) {
        rc = NOXTLS_RETURN_FAILED;
    }
    return rc;
}

/**
 * @brief Time ECDH on both backends and compare the secrets (and the peer's view of it).
 * @internal
 */
static void speed_case_ecdh(void)
{
    noxtls_speed_row_t *row = noxtls_speed_row_begin("p256_ecdh", 0U, 1U);
    uint8_t secret_sw[NOXTLS_SPEED_P256_BYTES];
    uint8_t secret_hw[NOXTLS_SPEED_P256_BYTES];
    uint8_t secret_peer[NOXTLS_SPEED_P256_BYTES];
    uint8_t ok = 1U;
    uint8_t match;
    uint32_t start;
    uint32_t activity;
    uint32_t i;

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    ok &= (speed_ecdh(&s_key_sw, &s_key_hw, secret_sw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_ecdh(&s_key_sw, &s_key_hw, secret_peer) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->sw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_HW);
    ok &= (speed_ecdh(&s_key_sw, &s_key_hw, secret_hw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    activity = noxtls_speed_hw_activity();
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_ecdh(&s_key_sw, &s_key_hw, secret_peer) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->hw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);
    row->hw_used = (noxtls_speed_hw_activity() != activity) ? 1U : 0U;

    /* The other party (reversed roles, hardware backend) must derive the same secret. */
    ok &= (speed_ecdh(&s_key_hw, &s_key_sw, secret_peer) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    match = ((memcmp(secret_sw, secret_hw, sizeof(secret_sw)) == 0) &&
             (memcmp(secret_sw, secret_peer, sizeof(secret_sw)) == 0)) ? 1U : 0U;

    row->run_ok = ok;
    row->match = match;
    noxtls_speed_row_end(row);
}

/**
 * @brief Sign the digest with the software key.
 * @internal
 *
 * @param[out] sig Signature.
 *
 * @return Library result.
 */
static noxtls_return_t speed_sign(ecdsa_signature_t *sig)
{
    return noxtls_ecdsa_sign_digest(&s_key_sw, s_digest, NOXTLS_SPEED_P256_BYTES, sig);
}

/**
 * @brief Verify a signature of the digest.
 * @internal
 *
 * @param[in] sig Signature.
 *
 * @return Library result.
 */
static noxtls_return_t speed_verify(const ecdsa_signature_t *sig)
{
    return noxtls_ecdsa_verify_digest(&s_key_sw, s_digest, NOXTLS_SPEED_P256_BYTES, sig);
}

/**
 * @brief Whether a signature verifies on the backend currently selected and a damaged digest is rejected.
 * @internal
 *
 * @param[in] sig Signature.
 *
 * @return 1 when valid and the damaged digest is rejected, 0 otherwise.
 */
static uint8_t speed_sig_accepted(const ecdsa_signature_t *sig)
{
    uint8_t damaged[NOXTLS_SPEED_P256_BYTES];
    uint8_t good = 0U;

    (void)memcpy(damaged, s_digest, sizeof(damaged));
    damaged[0] ^= 1U;
    if (speed_verify(sig) == NOXTLS_RETURN_SUCCESS) {
        good = (noxtls_ecdsa_verify_digest(&s_key_sw, damaged, NOXTLS_SPEED_P256_BYTES, sig) != NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    return good;
}

/**
 * @brief Time ECDSA signing on both backends; each signature must verify on both.
 * @internal
 */
static void speed_case_sign(void)
{
    noxtls_speed_row_t *row = noxtls_speed_row_begin("p256_ecdsa_sign", 0U, 1U);
    uint8_t ok = 1U;
    uint8_t match = 1U;
    uint32_t start;
    uint32_t activity;
    uint32_t i;

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    ok &= (speed_sign(&s_sig_sw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_sign(&s_sig_tmp) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->sw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_HW);
    ok &= (speed_sign(&s_sig_hw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    activity = noxtls_speed_hw_activity();
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_sign(&s_sig_tmp) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->hw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);
    row->hw_used = (noxtls_speed_hw_activity() != activity) ? 1U : 0U;

    /* Both signatures, on both backends. */
    match &= speed_sig_accepted(&s_sig_sw);
    match &= speed_sig_accepted(&s_sig_hw);
    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    match &= speed_sig_accepted(&s_sig_sw);
    match &= speed_sig_accepted(&s_sig_hw);

    row->run_ok = ok;
    row->match = match;
    noxtls_speed_row_end(row);
}

/**
 * @brief Time ECDSA verification of one signature on both backends.
 * @internal
 */
static void speed_case_verify(void)
{
    noxtls_speed_row_t *row = noxtls_speed_row_begin("p256_ecdsa_verify", 0U, 1U);
    uint8_t ok = 1U;
    uint8_t match = 1U;
    uint32_t start;
    uint32_t activity;
    uint32_t i;

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_SW);
    match &= speed_sig_accepted(&s_sig_hw);
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_verify(&s_sig_hw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->sw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);

    noxtls_speed_backend_set(NOXTLS_SPEED_BACKEND_HW);
    match &= speed_sig_accepted(&s_sig_hw);
    activity = noxtls_speed_hw_activity();
    start = noxtls_speed_timer_cycles();
    for (i = 0U; i < NOXTLS_SPEED_ITERS_ECC; i++) {
        ok &= (speed_verify(&s_sig_hw) == NOXTLS_RETURN_SUCCESS) ? 1U : 0U;
    }
    row->hw_cycles = noxtls_speed_avg(start, NOXTLS_SPEED_ITERS_ECC);
    row->hw_used = (noxtls_speed_hw_activity() != activity) ? 1U : 0U;

    row->run_ok = ok;
    row->match = match;
    noxtls_speed_row_end(row);
}

void noxtls_speed_run_pk(void)
{
    uint32_t i;

    for (i = 0U; i < NOXTLS_SPEED_P256_BYTES; i++) {
        s_digest[i] = (uint8_t)((i * SPEED_DIGEST_MUL) + SPEED_DIGEST_ADD);
    }
    speed_case_keygen();
    if ((s_have_sw != 0U) && (s_have_hw != 0U)) {
        speed_case_ecdh();
        speed_case_sign();
        speed_case_verify();
    } else {
        noxtls_speed_check("p256_keys_available", 0U);
    }
    speed_key_release(&s_key_sw, &s_have_sw);
    speed_key_release(&s_key_hw, &s_have_hw);
    speed_key_release(&s_key_tmp, &s_have_tmp);
}
