/* RFC 4493 section 4 KATs for one-shot and incremental AES-CMAC. */
#include <stdio.h>
#include <string.h>
#include "encryption/aes/noxtls_aes_cmac.h"

static const uint8_t key[16] = {
    0x2b,0x7e,0x15,0x16,0x28,0xae,0xd2,0xa6,
    0xab,0xf7,0x15,0x88,0x09,0xcf,0x4f,0x3c
};
static const uint8_t message[64] = {
    0x6b,0xc1,0xbe,0xe2,0x2e,0x40,0x9f,0x96,0xe9,0x3d,0x7e,0x11,0x73,0x93,0x17,0x2a,
    0xae,0x2d,0x8a,0x57,0x1e,0x03,0xac,0x9c,0x9e,0xb7,0x6f,0xac,0x45,0xaf,0x8e,0x51,
    0x30,0xc8,0x1c,0x46,0xa3,0x5c,0xe4,0x11,0xe5,0xfb,0xc1,0x19,0x1a,0x0a,0x52,0xef,
    0xf6,0x9f,0x24,0x45,0xdf,0x4f,0x9b,0x17,0xad,0x2b,0x41,0x7b,0xe6,0x6c,0x37,0x10
};
static const uint32_t lengths[4] = {0,16,40,64};
static const uint8_t expected[4][16] = {
    {0xbb,0x1d,0x69,0x29,0xe9,0x59,0x37,0x28,0x7f,0xa3,0x7d,0x12,0x9b,0x75,0x67,0x46},
    {0x07,0x0a,0x16,0xb4,0x6b,0x4d,0x41,0x44,0xf7,0x9b,0xdd,0x9d,0xd0,0x4a,0x28,0x7c},
    {0xdf,0xa6,0x67,0x47,0xde,0x9a,0xe6,0x30,0x30,0xca,0x32,0x61,0x14,0x97,0xc8,0x27},
    {0x51,0xf0,0xbe,0xbf,0x7e,0x3b,0x9d,0x92,0xfc,0x49,0x74,0x17,0x79,0x36,0x3c,0xfe}
};

int main(void)
{
    noxtls_aes_cmac_context_t ctx;
    uint8_t out[16];
    uint32_t vector, split;
    for(vector = 0; vector < 4; ++vector) {
        if(noxtls_aes_cmac(key, message, lengths[vector], out, NOXTLS_AES_128_BIT) !=
           NOXTLS_RETURN_SUCCESS || memcmp(out, expected[vector], 16) != 0) {
            fprintf(stderr, "FAIL: one-shot vector %u\n", (unsigned)vector); return 1;
        }
        for(split = 0; split <= lengths[vector]; ++split) {
            if(noxtls_aes_cmac_init(&ctx, key, NOXTLS_AES_128_BIT) != NOXTLS_RETURN_SUCCESS ||
               noxtls_aes_cmac_update(&ctx, message, split) != NOXTLS_RETURN_SUCCESS ||
               noxtls_aes_cmac_update(&ctx, NULL, 0) != NOXTLS_RETURN_SUCCESS ||
               noxtls_aes_cmac_update(&ctx, message + split, lengths[vector] - split) != NOXTLS_RETURN_SUCCESS ||
               noxtls_aes_cmac_final(&ctx, out) != NOXTLS_RETURN_SUCCESS ||
               memcmp(out, expected[vector], 16) != 0) {
                fprintf(stderr, "FAIL: streaming vector %u split %u\n",
                        (unsigned)vector, (unsigned)split); return 1;
            }
            if(noxtls_aes_cmac_final(&ctx, out) != NOXTLS_RETURN_NOT_INITIALIZED) return 1;
        }
    }
    memset(&ctx, 0, sizeof(ctx));
    if(noxtls_aes_cmac_init(NULL, key, NOXTLS_AES_128_BIT) != NOXTLS_RETURN_NULL ||
       noxtls_aes_cmac_init(&ctx, NULL, NOXTLS_AES_128_BIT) != NOXTLS_RETURN_NULL ||
       noxtls_aes_cmac_update(&ctx, message, 1) != NOXTLS_RETURN_NOT_INITIALIZED) return 1;
    puts("cmac_rfc4493_test: PASS");
    return 0;
}
